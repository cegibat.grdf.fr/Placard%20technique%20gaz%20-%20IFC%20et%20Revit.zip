Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-03-05T14:42:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 05 14:42:20 2018 * Host: JB-MSI * Database: C:\Users\JB\AppData\Local\Temp\{A983B4EA-6826-49DD-B6DA-B7DDDE30DC20}\ifc * Database version: 5507 * Database creation date: Mon Mar 05 14:42:18 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 05 14:42:19 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 05 14:42:19 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcBuildingElementProxy: Gaz naturel – Placard Technique Gaz (PTG), Gaz naturel – Placard Technique Gaz (PTG):Gaz naturel – Placard Technique Gaz (PTG):211508
In: Niveau 1
Type - Classification: D3010 Energy Supply (Uniformat); Material: GRDF Gris, GRDF Vert, GRDF Bleu
Type - Autre(Type) - Catégorie: Equipement de génie climatique; ARM.Coup.G.Haut: 20 mm; ARM.Coup.G.Implant.bas: 10 mm; ARM.Coup.G.Larg: 50 mm; ARM.Coup.G.Long: 50 mm; ARM.Det.Haut: 35 mm; ARM.Det.Larg: 90 mm; ARM.Det.Long: 100 mm; ARM.Det.Pos.bas: 50 mm; ARM.EP Fond: 30 mm; ARM.EP Portes: 20 mm; ARM.H Partie Haut: 30 mm; ARM.H Plinthe: 20 mm; ARM.H Ventil.Bas: 150 mm; ARM.H Ventil.Haut: 150 mm; ARM.Implant.grille.INT: 150 mm; ARM.Implant Vent.Bas: 150 mm; ARM.Implant Vent.Haut: 150 mm; ARM.L. Ventil: 250 mm; ARM.L Coté: 30 mm; ARM.Pos.gauche.DN.Aval: 150 mm; ARM.Pos.Haut.DN.Aval: 130 mm; ARM_CON_espacement: 50 mm; ARM_CON_pos_Bas: 60 mm; ARM_CON_pos_droite: 30 mm; ARM_CON_pos_haut: 50 mm; COMP.Implant.bas: 500 mm; COMP.Implant.Haut: 800 mm; Nom de la famille: Gaz naturel – Placard Technique Gaz (PTG); VENT.H.Ailette: 20 mm; VENT.L.Aillette: 250 mm; VENT.Larg.Ailette: 20 mm; Version.interieur: yes
Type - Cotes(Type) - ARM.Grille.INT.Cote: 10 mm; ARM.INT.Hauteur.grille: 300 mm; ARM.INT.Longueur.grille: 500 mm; ARM.Vent.INT.NB: 6; VENT.INT.Hauteur: 50 mm
Type - Données d'identification(Type) - Code d'assemblage: D3010; Commentaires du type: NC; Coût: 0; Description: PTGE; Description de l'assemblage: Energy Supply; Fabricant: NC; Marque: A remplir; Modèle: A remplir; Nom du type: Gaz naturel – Placard Technique Gaz (PTG); Note d'identification: NC; Reference produit: A remplir; URL: NC
Pset_BuildingElementProxyCommon - Reference: Gaz naturel – Placard Technique Gaz (PTG)
Pset_ManufacturerTypeInformation - Manufacturer: NC
Autre - 2D: no; ARM.Coup.G.Pos.Gauche: 125 mm; ARM.Coup.G.Pos.Haut: 105 mm; ARM.Det.Pos.Gauche: 100 mm; ARM.Det.Pos.Haut: 80 mm; ARM.Detendeur regulateur: yes; ARM.DN.Amont.nb.comp.1: 3; ARM.DN.Amont.nb.comp.2: 3; ARM.Fermee: yes; ARM.Fermee.EXT: no; ARM.Fermee.INT: yes; ARM.H.pieds: 150 mm; ARM.H Portes: 950 mm; ARM.L Porte: 470 mm; ARM.Ouv.EXT: no; ARM.Ouv.INT: no; ARM.Version.Exterieur: no; ARM-Coupure-general: yes; Catégorie: Equipement de génie climatique; Famille: Gaz naturel – Placard Technique Gaz (PTG): Gaz naturel – Placard Technique Gaz (PTG); Famille et type: Gaz naturel – Placard Technique Gaz (PTG): Gaz naturel – Placard Technique Gaz (PTG); ID du type: Gaz naturel – Placard Technique Gaz (PTG): Gaz naturel – Placard Technique Gaz (PTG); Type: Gaz naturel – Placard Technique Gaz (PTG): Gaz naturel – Placard Technique Gaz (PTG); VENT.Ep.Ailette: 2 mm; VENT.Nb.Ailette.Bas: 7; VENT.Nb.Ailettes Haut: 7
Contraintes - Date de mise en service: A remplir; Décalage: 0 mm; En savoir plus sur la conception: https://cegibat.grdf.fr/sites/default/files/tools/placard_technique_gaz_ptg.pdf; Hauteur: 1000 mm; Hôte: Niveau : Niveau 1; Largeur: 1000 mm; Lien vers les objets génériques au gaz naturel: https://cegibat.grdf.fr/dossier-techniques/conception-batiments/objets-bim-gaz-naturel; Niveau: Niveau: Niveau 1; Nombre de compteurs: 6; Portes ouvertes: no; Profondeur: 270 mm
Cotes - Surface: 6.12707 m2; Volume: 0.0750233 m3
Données - ARM.PART.Hauteur: 1000 mm; ARM.PART.Longueur: 1000 mm; ARM.PART.Nb.Compteurs: 6; ARM.PART.Profondeur: 270 mm
Données d'identification - Identifiant: 4
Génie climatique - Classification du système: Non défini
Génie climatique - Ecoulement - ARM.DN.Aval: 50 mm; COMP.10 Débit MAX (L/s): 0.0589755 m3/s; COMP.1 Débit MAX (L/s): 0.0589755 m3/s; COMP.2 Débit MAX (L/s): 0.0589755 m3/s; COMP.3 Débit MAX (L/s): 0.0589755 m3/s; COMP.4 Débit MAX (L/s): 0.0589755 m3/s; COMP.5 Débit MAX (L/s): 0.0589755 m3/s; COMP.6 Débit MAX (L/s): 0.0589755 m3/s; COMP.7 Débit MAX (L/s): 0.0589755 m3/s; COMP.8 Débit MAX (L/s): 0.0589755 m3/s; COMP.9 Débit MAX (L/s): 0.0589755 m3/s
Matériaux et finitions - COOF.Metal: GRDF Gris
Phase de construction - Phase de création: Nouvelle construction
